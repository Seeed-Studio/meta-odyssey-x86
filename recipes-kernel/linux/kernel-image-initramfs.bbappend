do_install_append(){
        mv  ${D}/boot/bzImage  ${D}/boot/bzImage-1
}

