SUMMARY = "A console-only image that fully supports the odyssey-x86 device \
and mender.io cloud."

IMAGE_FEATURES += "splash"


inherit odyssey-image
