
INTERNAL_DEVICE_KERNEL = "sda"
